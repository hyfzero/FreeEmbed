# Keil uVision project EZPro100_v20.uvprojx, settings and files
target EZPro100_v20 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8004000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: EZPro100_v20 +hex
  AfterMake: fromelf --m32 --output .\Objects\EZPro100_APP_v20.srec .\Objects\EZPro100_v20.axf
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_STM3210E_EVAL,SINOMCU_IAP
  c undefine: STM32F10X_XL
  c misc: --signed_chars
  c include: .;..\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL;..\UserModules\hw_abstraction\storage\include;..\UserModules\hw_abstraction\bus\spi\include;..\UserModules\hw_abstraction\bus\i2c\include;..\UserModules\hw_abstraction\common\include
  memory RVCT4: ROM 0x8004000 size 0xfc000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Startup
    ./: startup_stm32f10x_hd.s
  group CMSIS
    ./: stm32f10x.h
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../src/: system_stm32f10x.c
  group User
    ../src/: ADC.c Config.c delay.c global.c hw_config.c IRC.c lcd.c main.c MC301Pro.c MC30F6910.c MC32P21Pro.c MC32P5232Pro.c MTPRW.c OTPRW.c power.c spi.c stm32f10x_it.c test.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c USB_Rx_Tx.c wx_i2c.c
  group HwAbstraction
    ../UserModules/hw_abstraction/storage/src/: storage.c
    ../UserModules/hw_abstraction/bus/spi/src/: spi_transport.c
    ../UserModules/hw_abstraction/bus/i2c/src/: i2c_transport.c
  group STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
  group Doc
    ../: readme.txt
    ./: Keil_Conversion.md gen_srec.bat
